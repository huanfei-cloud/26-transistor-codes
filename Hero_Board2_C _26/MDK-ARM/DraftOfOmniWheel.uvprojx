# Keil uVision project DraftOfOmniWheel.uvprojx, settings and files
target DraftOfOmniWheel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: DraftOfOmniWheel +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_CM4,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Algorithm/Algorithm.h;../APPs/APPs.h;../BSP/BSP.h;../Devices/Devices.h;../Protocol/Protocol.h;../Tasks/Tasks.h;../Debug/TraceRecorder/include;../Debug/TraceRecorder/config;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Debug Assist\Debug Assist.h
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Algorithm
    ../Algorithm/Algorithm.c/: FeedForward.c kalman_filter.c pid.c user_lib.c FuzzyPID.c Gimbal_Chassis_Pitch_Angle.c
    ../Algorithm/Algorithm.h/: FeedForward.h kalman_filter.h pid.h user_lib.h FuzzyPID.h Gimbal_Chassis_Pitch_Angle.h
  group Protocol
    ../Protocol/Protocol.c/: BSP_BoardCommunication.c Protocol_Judgement.c UI.c
    ../Protocol/Protocol.h/: BSP_BoardCommunication.h Protocol_Judgement.h UI.h
  group BSP
    ../BSP/BSP.c/: BSP_Can.c bsp_delay.c bsp_led.c BSP_Test.c BSP_Usart.c
    ../BSP/BSP.h/: BSP_Can.h bsp_delay.h bsp_led.h BSP_Test.h BSP_Usart.h typedef.h
  group Devices
    ../Devices/Devices.c/: Saber_C3.c N100.c DT7.c MA600_use.c MA600_base.c M3508_Motor.c M6020_Motor.c M2006_Motor.c J4310_Motor.c
    ../Devices/Devices.h/: Saber_C3.h N100.h DT7.h MA600_base.h MA600_use.h M3508_Motor.h M6020_Motor.h M2006_Motor.h J4310_Motor.h
  group APPs
    ../APPs/APPs.c/: Cloud_Control.c Time_Stamp.c PowerControl.c steer_chassis.c
    ../APPs/APPs.h/: Cloud_Control.h Time_Stamp.h PowerControl.h steer_chassis.h
  group Tasks
    ../Tasks/Tasks.c/: Task_CanReceive.c Task_CanSend.c Task_LED.c Task_RobotControl.c Task_UsartSend.c Task_RobotUI.c Task_OffLineCheck.c Task_SPI2Receive.c Task_Vofa.c
    ../Tasks/Tasks.h/: Task_CanReceive.h Task_CanSend.h Task_LED.h Task_RobotControl.h Task_UsartSend.h Task_RobotUI.h Task_OffLineCheck.h Task_SPI2Receive.h Task_Vofa.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group Debug Assist
    ../Debug Assist/Debug Assist.c/: sys.c vofa.c
    ../Debug Assist/Debug Assist.h/: sys.h vofa.h
software components: CMSIS:CORE 6.1.0
