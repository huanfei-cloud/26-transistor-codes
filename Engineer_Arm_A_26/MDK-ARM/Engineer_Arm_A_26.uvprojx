# Keil uVision project Engineer_Arm_A_26.uvprojx, settings and files
target Engineer_Arm_A_26 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Engineer_Arm_A_26 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Algorithm/Algorithm.h;../Apps/Apps.h;../BSP/BSP.h;..\Debug Assist\Debug Assist.h;../Devices/Device.h;../Tasks/Tasks.h;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Algorithm
    ../Algorithm/Algorithm.c/: pid.c
    ../Algorithm/Algorithm.h/: pid.h
  group Apps
    ../Apps/Apps.c/: Arm_Control.c
    ../Apps/Apps.h/: Arm_Control.h struct_typedef.h
  group BSP
    ../BSP/BSP.c/: BSP_Can.c BSP_Delay.c BSP_led.c BSP_Usart.c
    ../BSP/BSP.h/: BSP_Can.h BSP_Delay.h BSP_led.h BSP_Usart.h typedef.h
  group Devices
    ../Devices/Device.c/: DT7.c DJ_Motor.c DM_Motor.c
    ../Devices/Device.h/: DT7.h DJ_Motor.h DM_Motor.h
  group Debug Assists
    ../Debug Assist/Debug Assist.c/: sys.c vofa.c
    ../Debug Assist/Debug Assist.h/: sys.h vofa.h
  group Tasks
    ../Tasks/Tasks.c/: Task_ArmControl.c Task_CanReceive.c Task_CanSend.c Task_LED.c Task_Vofa.c
    ../Tasks/Tasks.h/: Task_ArmControl.h Task_CanReceive.h Task_CanSend.h Task_LED.h Task_Vofa.h Task_UsartSend.h Task_OfflineCheck.h Extern_Handles.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
